# Keil uVision project ValveX2.uvprojx, settings and files
target ValveX2 (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ValveX2 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD
  c include: ..\SRC\APP;..\SRC\HARDWARE\stmFlash;..\SRC\HARDWARE\usinterface;..\SRC\SYSTEM\delay;..\SRC\SYSTEM\sys;..\SRC\SYSTEM\timer;..\SRC\SYSTEM\usart;..\SRC\CMSIS\CoreSupport;..\SRC\CMSIS\DeviceSupport;..\SRC\HARDWARE\motor;..\SRC\HARDWARE\EEPROM;..\SRC\HARDWARE\Modbus
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group StartUp
    ../SRC/CMSIS/DeviceSupport/StartUp/: startup_stm32f10x_md.s
  group APP
    ../SRC/APP/: main.c app.h
  group HW
    ../SRC/HARDWARE/stmFlash/: stmflash.c
    ../SRC/HARDWARE/motor/: motor.c Smotor.lib
    ../SRC/HARDWARE/usinterface/: usFunc.c USINTF_CR.lib
    ../SRC/HARDWARE/EEPROM/: EEP24Serial.c
    ../SRC/HARDWARE/Modbus/: modbus.c ModBusCrc16.c
  group SYS
    ../SRC/SYSTEM/delay/: delay.c
    ../SRC/SYSTEM/sys/: sys.c
    ../SRC/SYSTEM/timer/: timer.c
    ../SRC/SYSTEM/usart/: usart.c
  group Doc
    ../Doc/: ValveX2_v1.3.1修改说明.md
