# Keil uVision project QHF.uvprojx, settings and files
target O_901 (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: QHF +hex
  AfterMake: E:\workdir\zym_new\general-switcher\keil-build-viewer.exe
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,O_901
  c include: ..\SRC\APP;..\SRC\HARDWARE\stmFlash;..\SRC\HARDWARE\usinterface;..\SRC\SYSTEM\delay;..\SRC\SYSTEM\sys;..\SRC\SYSTEM\timer;..\SRC\SYSTEM\usart;..\SRC\CMSIS\CoreSupport;..\SRC\CMSIS\DeviceSupport;..\SRC\HARDWARE\motor;..\SRC\HARDWARE\EEPROM;..\SRC\HARDWARE\Modbus;..\SRC\HARDWARE\ags_mb;..\SRC\HARDWARE\io
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group StartUp
    ../SRC/CMSIS/DeviceSupport/StartUp/: startup_stm32f10x_md.s
  group APP
    ../SRC/APP/: main.c app.h
  group HW
    ../SRC/HARDWARE/stmFlash/: stmflash.c
    ../SRC/HARDWARE/motor/: motor.c Smotor.lib
    ../SRC/HARDWARE/usinterface/: usFunc.c USINTF_CR.lib
    ../SRC/HARDWARE/EEPROM/: EEP24Serial.c
    ../SRC/HARDWARE/ags_mb/: ags_mb.c ModBusCrc16.c
    ../SRC/HARDWARE/modbus/: modbus.c
    ../SRC/HARDWARE/io/: bsp_io.c
  group SYS
    ../SRC/SYSTEM/delay/: delay.c
    ../SRC/SYSTEM/sys/: sys.c
    ../SRC/SYSTEM/timer/: timer.c
    ../SRC/SYSTEM/usart/: usart.c
  group Doc
    ../Doc/: QHF_v1.3.1修改说明.md
  group 3rd/xfusion
    ../SRC/3rd/xfusion/xf_utils_log/: xf_utils_log_dump.c
  group elab/common
    ../SRC/3rd/common/: elab_log.c elab_common.c
target O_906 (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: as above
  output: QHF +hex
  AfterMake: E:\workdir\zym_new\general-switcher\keil-build-viewer.exe
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,O_906
  c include: ..\SRC\APP;..\SRC\HARDWARE\stmFlash;..\SRC\HARDWARE\usinterface;..\SRC\SYSTEM\delay;..\SRC\SYSTEM\sys;..\SRC\SYSTEM\timer;..\SRC\SYSTEM\usart;..\SRC\CMSIS\CoreSupport;..\SRC\CMSIS\DeviceSupport;..\SRC\HARDWARE\motor;..\SRC\HARDWARE\EEPROM;..\SRC\HARDWARE\ags_mb;..\SRC\HARDWARE\Modbus;..\SRC\HARDWARE\io;..\SRC\Board
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
target O_909 (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: as above
  output: QHF +hex
  AfterMake: E:\workdir\zym_new\general-switcher\keil-build-viewer.exe
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,O_909
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
target A_901 (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: as above
  output: QHF +hex
  AfterMake: E:\workdir\zym_new\general-switcher\keil-build-viewer.exe
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,A_901
  c include: ..\SRC\APP;..\SRC\HARDWARE\stmFlash;..\SRC\HARDWARE\usinterface;..\SRC\SYSTEM\delay;..\SRC\SYSTEM\sys;..\SRC\SYSTEM\timer;..\SRC\SYSTEM\usart;..\SRC\CMSIS\CoreSupport;..\SRC\CMSIS\DeviceSupport;..\SRC\HARDWARE\motor;..\SRC\HARDWARE\EEPROM;..\SRC\HARDWARE\Modbus;..\SRC\HARDWARE\ags_mb;..\SRC\HARDWARE\io;..\SRC\3rd\common;..\SRC\3rd\xfusion\xf_common;..\SRC\3rd\xfusion\xf_utils_log
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
target A_906 (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: as above
  output: QHF +hex
  AfterMake: E:\workdir\zym_new\general-switcher\keil-build-viewer.exe
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,A_906
  c include: ..\SRC\APP;..\SRC\HARDWARE\stmFlash;..\SRC\HARDWARE\usinterface;..\SRC\SYSTEM\delay;..\SRC\SYSTEM\sys;..\SRC\SYSTEM\timer;..\SRC\SYSTEM\usart;..\SRC\CMSIS\CoreSupport;..\SRC\CMSIS\DeviceSupport;..\SRC\HARDWARE\motor;..\SRC\HARDWARE\EEPROM;..\SRC\HARDWARE\Modbus;..\SRC\HARDWARE\ags_mb;..\SRC\3rd\common;..\SRC\3rd\xfusion\xf_common;..\SRC\3rd\xfusion\xf_utils_log;..\SRC\3rd\xfusion;..\SRC\HARDWARE\io
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
target A_909 (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: as above
  output: QHF +hex
  AfterMake: E:\workdir\zym_new\general-switcher\keil-build-viewer.exe
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,A_909
  c include: ..\SRC\APP;..\SRC\HARDWARE\stmFlash;..\SRC\HARDWARE\usinterface;..\SRC\SYSTEM\delay;..\SRC\SYSTEM\sys;..\SRC\SYSTEM\timer;..\SRC\SYSTEM\usart;..\SRC\CMSIS\CoreSupport;..\SRC\CMSIS\DeviceSupport;..\SRC\HARDWARE\motor;..\SRC\HARDWARE\EEPROM;..\SRC\HARDWARE\Modbus;..\SRC\HARDWARE\ags_mb;..\SRC\3rd\xfusion\xf_common;..\SRC\3rd\xfusion\xf_utils_log;..\SRC\3rd\common;..\SRC\HARDWARE\io
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
target B_901 (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: as above
  output: QHF +hex
  AfterMake: E:\workdir\zym_new\general-switcher\keil-build-viewer.exe
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,B_901
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
target B_906 (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: as above
  output: QHF +hex
  AfterMake: E:\workdir\zym_new\general-switcher\keil-build-viewer.exe
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,B_906
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
target C_901 (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: as above
  output: QHF +hex
  AfterMake: E:\workdir\zym_new\general-switcher\keil-build-viewer.exe
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,C_901
  c include: ..\SRC\APP;..\SRC\HARDWARE\stmFlash;..\SRC\HARDWARE\usinterface;..\SRC\SYSTEM\delay;..\SRC\SYSTEM\sys;..\SRC\SYSTEM\timer;..\SRC\SYSTEM\usart;..\SRC\CMSIS\CoreSupport;..\SRC\CMSIS\DeviceSupport;..\SRC\HARDWARE\motor;..\SRC\HARDWARE\EEPROM;..\SRC\HARDWARE\ags_mb;..\SRC\HARDWARE\Modbus;..\SRC\HARDWARE\io;..\SRC\3rd\common;..\SRC\3rd\xfusion\xf_common;..\SRC\3rd\xfusion\xf_utils_log
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
